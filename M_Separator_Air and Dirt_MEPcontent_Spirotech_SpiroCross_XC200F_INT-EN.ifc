Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC200F_INT-EN.ifc
Time: 2025-08-05T18:33:40+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2152125_3
Port_2152125_4
Port_2152125_7
Port_2152125_8

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN:XC200F, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN:XC200F:2152125
In: F00
Type - Material: Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Base Flange: 16 mm; Base Flange Radius: 109.55 mm; Bottom Geomtry Height: 95 mm; Brackets Height: 25 mm; Chamfer Radius: 81.2 mm; Cone Flange: 22 mm; Cone Flange Radius Bottom: 124.5 mm; Cone Flange Radius Top: 109.55 mm; Connection Diameter: 201 mm; Distance Between Brackets: 295 mm; DN: 201 mm; Drain Height: 170 mm; Drain Offset: 131 mm; Drain Radius: 16.85 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN; Flange Body: 21 mm; Flange Body Radius: 170 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 134 mm; Front Bracket Height: 60.0027 mm; Front Bracket Offset: 184.003 mm; Front Bracket Offset 2: 203 mm; h: 675 mm; H1: 465 mm; h2: 776 mm; h3: 170 mm; Inner Diameter Ring: 10 mm; OD: 219.1 mm; Outer Diameter Bracket: 54 mm; Type Value: 13; Upper Geometry Radius: 12 mm; Upper Side Height: 674 mm; Width: 534 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 406 mm; H: 2321 mm; L: 651 mm; LF: 775 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Low-loss Header with Deaerator & dirt separator - Steel - Flange DN200; Article Type: XC200F; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low-loss Header with Deaerator & dirt separator - Steel - Flange DN200; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811015650; Manufacturer: Spirotech; Manufacturer Art. No.: XC200F; Manufacturer URL: https://www.spirotech.com/8717811015650; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: XC200F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: XC200F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.05 m3/s; Pressure Stage: 16; Volume: 0.252 m3; Weight: 274 kg
Type - Mechanical - Flow - Pressure Drop: 5800 Pa
Type - Visibility - Flange: yes; Front Bracket: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: XC200F; sets with these values: 2
Other - Bottom Clearance Safe: 100 mm; Connection Length: 775 mm; Connectors Length: 775 mm; Connectors Length Safe: 786 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN: XC200F; Length: 775 mm; Top Clearance Safe: 50 mm; Type: XC200F; Type Id: 2152080
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 3.64839 m2; Maximum Size: 201 mm; Minimum Size: 201 mm; Volume: 0.318646 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow In 2: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 100 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
